# Keil uVision project USB-HOST_485_V1.2.uvprojx, settings and files
target Target2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB-HOST_485_V1_2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xB
  c misc: --C99
  c include: .\Inc;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;.\Middlewares\ST\STM32_USB_Host_Library\Class\CDC\Inc;.\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User
    ./Src/: usbh_conf.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_host.c main.c usart_execute.c flash_execute.c system_init.c
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Middlewares/USB_Host_Library
    ./Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c usbh_core.c
    ./Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
  group Drivers/CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_ll_usb.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c
software components: CMSIS:CORE 3.40.0
